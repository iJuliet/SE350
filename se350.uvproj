# Keil uVision project se350.uvproj, settings and files
target SE350 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: se350
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s
  group System Code
    ./: system_LPC17xx.c
  group Source Code
    ./: uart_polling.c HAL.c k_rtx_init.c main_svc.c printf.c usr_proc.c k_memory.c k_process.c timer.c uart_irq.c message.c cmd_proc.c
